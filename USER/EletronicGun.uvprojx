# Keil uVision project EletronicGun.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USMART +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\CORE;..\USMART;..\USER;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\Menu;..\HARDWARE\MyVariable;..\HARDWARE\Steer;..\SYSTEM\UART4;..\HARDWARE\AnoTC;..\HARDWARE\TIM6_Base;..\HARDWARE\Control;..\HARDWARE\PID;..\SYSTEM\USART2;..\HARDWARE\DC_Control
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/MyVariable/: MyVariable.c
    ../HARDWARE/AnoTC/: AnoTc.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Menu/: Menu.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/Steer/: TIM4_PWM.C
    ../HARDWARE/TIM6_Base/: TIM6_Base.c
    ../HARDWARE/PID/: PID.c
    ../HARDWARE/Control/: Control.C
    ../HARDWARE/DC_Control/: DC_Control.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/UART4/: UART4.C
    ../SYSTEM/USART2/: USART2.C
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_spi.c
